# Keil uVision project Bat_man.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: STM32F767ZITx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.16.0
  cpu: IRAM(0x20020000,0x60000) IRAM2(0x20000000,0x20000) IROM(0x08000000,0x200000) IROM2(0x00200000,0x200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: Bat_man
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20020000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x20000
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32F767ZITx/STCubeGenerated/Src/: main.c stm32f7xx_it.c
    ./RTE/Device/STM32F767ZITx/STCubeGenerated/Inc/: stm32f7xx_it.h
software components: CMSIS:CORE 6.1.0, Device:STM32Cube Framework:STM32CubeMX 1.1.0, Device:STM32Cube HAL:CAN 1.3.0, Device:STM32Cube HAL:Common 1.3.0, Device:STM32Cube HAL:Cortex 1.3.0, Device:STM32Cube HAL:DMA 1.3.0, Device:STM32Cube HAL:ETH 1.3.0, Device:STM32Cube HAL:GPIO 1.3.0, Device:STM32Cube HAL:PWR 1.3.0, Device:STM32Cube HAL:RCC 1.3.0, Device:STM32Cube HAL:SPI 1.3.0, Device:STM32Cube HAL:UART 1.3.0, Device:STM32Cube HAL:USART 1.3.0, Device:Startup 1.2.5
